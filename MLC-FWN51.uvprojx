# Keil uVision project MLC-FWN51.uvprojx, settings and files
target MLC-FWN51 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM(0-0x3FF) CLOCK(24000000)
  output: MLC-FWN51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  link misc: REMOVEUNUSED
  group Application
    ./src/: main.c ir_rx.c
  group Library
    ./lib/: Common.c Delay.c
  group Startup
    ./startup/: STARTUP.A51
